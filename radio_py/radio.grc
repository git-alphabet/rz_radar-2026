options:
  parameters:
    generate_options: qt_gui
    id: radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: pluto_uri
  id: variable
  parameters:
    comment: ip address
    value: '"ip:192.168.1.10"'
  states: {}
- name: red_sensitivity
  id: variable
  parameters:
    value: '1.5756'
  states: {}
- name: rx_center_freq
  id: variable
  parameters:
    comment: 'Red info source: 433.2e6; blue info source: 433.92e6'
    value: 433.2e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: Pluto RX manual gain, tune on field
    value: '60'
  states: {}
- name: rx_rf_bandwidth
  id: variable
  parameters:
    comment: 0.6e6 to 0.8e6 for 0.54 MHz info wave
    value: 0.7e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_attenuation
  id: variable
  parameters:
    comment: Pluto TX attenuation in dB. Keep high for bench tests.
    value: '20'
  states: {}
- name: tx_center_freq
  id: variable
  parameters:
    comment: 'Simulator TX frequency. Red info: 433.2e6; blue info: 433.92e6'
    value: 433.2e6
  states: {}
- name: tx_rf_bandwidth
  id: variable
  parameters:
    comment: Simulator TX RF bandwidth
    value: 0.7e6
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '65536'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''0010111101101111010011000111010010111001000101000100100100101110'''
    comment: Bit-level sync on the official info-wave Access Code 0x2F6F4C74B914492E
    tagname: '"frame_start"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '52'
    sensitivity: red_sensitivity
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '52'
    sensitivity: red_sensitivity
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.insert(0, "/home/robomaster/Downloads/radar_radio_FixedWithGRC&Code")
      from gr_air_frame_extractor import AccessCodeBitFrameExtractor
    comment: Emits aligned 27-byte air frames after Access Code tagging.
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: int(tx_rf_bandwidth)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(tx_center_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: pluto_uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(rx_rf_bandwidth)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(rx_center_freq)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: pluto_uri
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 270e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HANN
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '27'
    port: '55557'
    send_eof: 'False'
    type: byte
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '27'
    port: '55555'
    src_zeros: 'False'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: 滤波前
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: 滤波后
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: 原始发送
    size: '501'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"原始接收"'
    size: '501'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: 原始字节
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: 原始恢复字节
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', network_udp_sink_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', epy_block_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_gfsk_mod_0, '0', iio_pluto_sink_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_repack_bits_bb_0, '0']
- [iio_pluto_source_0, '0', dc_blocker_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [network_udp_source_0, '0', blocks_uchar_to_float_0, '0']
- [network_udp_source_0, '0', digital_gfsk_mod_0, '0']

metadata:
  file_format: 1
