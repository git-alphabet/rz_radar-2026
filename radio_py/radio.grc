options:
  parameters:
    generate_options: qt_gui
    id: radio
    output_language: python
    title: Blue radar four-wave receiver
  states: {}

blocks:
- name: channel_samp_rate
  id: variable
  parameters:
    comment: Per-wave sample rate after Frequency Xlating FIR decimation
    value: samp_rate / xlate_decim
  states: {}
- name: channel_transition
  id: variable
  parameters:
    comment: Digital channel filter transition width
    value: 20e3
  states: {}
- name: info_cutoff
  id: variable
  parameters:
    comment: Blue info bandwidth 0.54 MHz / 2
    value: 0.27e6
  states: {}
- name: info_freq
  id: variable
  parameters:
    comment: Blue broadcast/info-wave center from table
    value: 433.920e6
  states: {}
- name: info_offset
  id: variable
  parameters:
    comment: Frequency Xlating FIR offset for blue info wave
    value: info_freq - rx_center_freq
  states: {}
- name: info_sensitivity
  id: variable
  parameters:
    comment: Blue info sensitivity from table, rad/sample at 1 MS/s
    value: '1.5756'
  states: {}
- name: jam1_cutoff
  id: variable
  parameters:
    comment: Blue level-1 jamming bandwidth 0.94 MHz / 2
    value: 0.47e6
  states: {}
- name: jam1_freq
  id: variable
  parameters:
    comment: Blue level-1 jamming center from table
    value: 434.920e6
  states: {}
- name: jam1_offset
  id: variable
  parameters:
    comment: Frequency Xlating FIR offset for level-1 jamming wave
    value: jam1_freq - rx_center_freq
  states: {}
- name: jam1_sensitivity
  id: variable
  parameters:
    comment: Blue level-1 jamming sensitivity from table, rad/sample at 1 MS/s
    value: '2.8323'
  states: {}
- name: jam2_cutoff
  id: variable
  parameters:
    comment: Blue level-2 jamming bandwidth 0.86 MHz / 2
    value: 0.43e6
  states: {}
- name: jam2_freq
  id: variable
  parameters:
    comment: Blue level-2 jamming center from table
    value: 434.620e6
  states: {}
- name: jam2_offset
  id: variable
  parameters:
    comment: Frequency Xlating FIR offset for level-2 jamming wave
    value: jam2_freq - rx_center_freq
  states: {}
- name: jam2_sensitivity
  id: variable
  parameters:
    comment: Blue level-2 jamming sensitivity from table, rad/sample at 1 MS/s
    value: '2.5809'
  states: {}
- name: jam3_cutoff
  id: variable
  parameters:
    comment: Blue level-3 jamming bandwidth 0.25 MHz / 2
    value: 0.18e6
  states: {}
- name: jam3_freq
  id: variable
  parameters:
    comment: Blue level-3 jamming center from table
    value: 434.320e6
  states: {}
- name: jam3_offset
  id: variable
  parameters:
    comment: Frequency Xlating FIR offset for level-3 jamming wave
    value: jam3_freq - rx_center_freq
  states: {}
- name: jam3_sensitivity
  id: variable
  parameters:
    comment: Blue level-3 jamming sensitivity from table, rad/sample at 1 MS/s
    value: '0.6646'
  states: {}
- name: pluto_uri
  id: variable
  parameters:
    comment: AntSDR/Pluto-compatible IIO URI
    value: '"ip:192.168.1.10"'
  states: {}
- name: rx_center_freq
  id: variable
  parameters:
    comment: Wideband LO center covering blue info + three jamming waves
    value: 434.520e6
  states: {}
- name: rx_info_gain
  id: variable
  parameters:
    comment: RX1/manual gain for weak blue info wave; tune on field
    value: '35'
  states: {}
- name: rx_jam_gain
  id: variable
  parameters:
    comment: RX2/manual gain for weak over-air replay of jamming waves; lower if overloaded
    value: '65'
  states: {}
- name: rx_rf_bandwidth
  id: variable
  parameters:
    comment: Analog RF bandwidth wide enough for 433.65..435.39 MHz occupied span
    value: 2.0e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RF sample rate shared with the RX_BLUE_ganrao_3 replay transmitter
    value: 2e6
  states: {}
- name: xlate_decim
  id: variable
  parameters:
    comment: 2 MS/s / 2 = 1 MS/s per GFSK demod chain
    value: '2'
  states: {}
- name: blocks_repack_bits_bb_info
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_jam1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_jam2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_jam3
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: digital_correlate_access_code_tag_xx_info
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''0010111101101111010011000111010010111001000101000100100100101110'''
    comment: Bit sync for Blue info/broadcast 433.920 MHz
    tagname: '"frame_start"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_jam1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''0001011011101000110100110111011100010101000111000111000100101101'''
    comment: Bit sync for Blue level-1 jamming 434.920 MHz
    tagname: '"frame_start"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_jam2
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''0001011011101000110100110111011100010101000111000111000100101101'''
    comment: Bit sync for Blue level-2 jamming 434.620 MHz
    tagname: '"frame_start"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_jam3
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '''0001011011101000110100110111011100010101000111000111000100101101'''
    comment: Bit sync for Blue level-3 jamming 434.320 MHz
    tagname: '"frame_start"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_gfsk_demod_info
  id: digital_gfsk_demod
  parameters:
    comment: 'Table parameters: Sample Rate 1M, SPS 52, BT 0.35.'
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '52'
    sensitivity: info_sensitivity
  states: {}
- name: digital_gfsk_demod_jam1
  id: digital_gfsk_demod
  parameters:
    comment: 'Table parameters: Sample Rate 1M, SPS 52, BT 0.35.'
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '52'
    sensitivity: jam1_sensitivity
  states: {}
- name: digital_gfsk_demod_jam2
  id: digital_gfsk_demod
  parameters:
    comment: 'Table parameters: Sample Rate 1M, SPS 52, BT 0.35.'
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '52'
    sensitivity: jam2_sensitivity
  states: {}
- name: digital_gfsk_demod_jam3
  id: digital_gfsk_demod
  parameters:
    comment: 'Table parameters: Sample Rate 1M, SPS 52, BT 0.35.'
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '52'
    sensitivity: jam3_sensitivity
  states: {}
- name: epy_block_info
  id: epy_block
  parameters:
    _source_code: |
      import os
      import sys

      _module_file = globals().get(
          "__file__",
          r"/home/alphabet/rz_radar-2026/radio_py/gr_air_frame_extractor.py",
      )
      _module_dir = os.path.dirname(os.path.abspath(_module_file))
      if _module_dir not in sys.path:
          sys.path.insert(0, _module_dir)

      from gr_air_frame_extractor import AccessCodeBitFrameExtractor
    access_code_hex: '"2F6F4C74B914492E"'
    bit_order: '"msb"'
    frame_bytes: '27'
    header_hex: '"000F000F"'
    output_mode: '"bits"'
  states: {}
- name: epy_block_jam1
  id: epy_block
  parameters:
    _source_code: |
      import os
      import sys

      _module_file = globals().get(
          "__file__",
          r"/home/alphabet/rz_radar-2026/radio_py/gr_air_frame_extractor.py",
      )
      _module_dir = os.path.dirname(os.path.abspath(_module_file))
      if _module_dir not in sys.path:
          sys.path.insert(0, _module_dir)

      from gr_air_frame_extractor import AccessCodeBitFrameExtractor
    access_code_hex: '"16E8D377151C712D"'
    bit_order: '"msb"'
    frame_bytes: '27'
    header_hex: '"000F000F"'
    output_mode: '"bits"'
  states: {}
- name: epy_block_jam2
  id: epy_block
  parameters:
    _source_code: |
      import os
      import sys

      _module_file = globals().get(
          "__file__",
          r"/home/alphabet/rz_radar-2026/radio_py/gr_air_frame_extractor.py",
      )
      _module_dir = os.path.dirname(os.path.abspath(_module_file))
      if _module_dir not in sys.path:
          sys.path.insert(0, _module_dir)

      from gr_air_frame_extractor import AccessCodeBitFrameExtractor
    access_code_hex: '"16E8D377151C712D"'
    bit_order: '"msb"'
    frame_bytes: '27'
    header_hex: '"000F000F"'
    output_mode: '"bits"'
  states: {}
- name: epy_block_jam3
  id: epy_block
  parameters:
    _source_code: |
      import os
      import sys

      _module_file = globals().get(
          "__file__",
          r"/home/alphabet/rz_radar-2026/radio_py/gr_air_frame_extractor.py",
      )
      _module_dir = os.path.dirname(os.path.abspath(_module_file))
      if _module_dir not in sys.path:
          sys.path.insert(0, _module_dir)

      from gr_air_frame_extractor import AccessCodeBitFrameExtractor
    access_code_hex: '"16E8D377151C712D"'
    bit_order: '"msb"'
    frame_bytes: '27'
    header_hex: '"000F000F"'
    output_mode: '"bits"'
  states: {}
- name: freq_xlating_fir_filter_info
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: info_offset
    comment: Translate this RF wave to 0 Hz and decimate 4 MS/s to 1 MS/s before GFSK demod.
    decim: xlate_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, info_cutoff, channel_transition, window.WIN_HAMMING, 6.76)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_jam1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: jam1_offset
    comment: Translate this RF wave to 0 Hz and decimate 4 MS/s to 1 MS/s before GFSK demod.
    decim: xlate_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, jam1_cutoff, channel_transition, window.WIN_HAMMING, 6.76)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_jam2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: jam2_offset
    comment: Translate this RF wave to 0 Hz and decimate 4 MS/s to 1 MS/s before GFSK demod.
    decim: xlate_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, jam2_cutoff, channel_transition, window.WIN_HAMMING, 6.76)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_jam3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: jam3_offset
    comment: Translate this RF wave to 0 Hz and decimate 4 MS/s to 1 MS/s before GFSK demod.
    decim: xlate_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, jam3_cutoff, channel_transition, window.WIN_HAMMING, 6.76)
    type: ccf
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: int(rx_rf_bandwidth)
    bbdc: 'True'
    buffer_size: '32768'
    comment: RX1 is for weak info wave, RX2 is for strong jamming waves.
    filter_source: '''Design'''
    fpass: 0.90e6
    frequency: int(rx_center_freq)
    fstop: 0.98e6
    gain1: '''manual'''
    gain2: '''manual'''
    manual_gain1: rx_info_gain
    manual_gain2: rx_jam_gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'False'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: pluto_uri
  states: {}
- name: network_udp_sink_info
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '27'
    port: '55557'
    send_eof: 'False'
    type: byte
  states: {}
- name: network_udp_sink_jam1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '27'
    port: '55558'
    send_eof: 'False'
    type: byte
  states: {}
- name: network_udp_sink_jam2
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '27'
    port: '55559'
    send_eof: 'False'
    type: byte
  states: {}
- name: network_udp_sink_jam3
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '27'
    port: '55560'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"information"'
    size: '1024'
    srate: channel_samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"disturb1"'
    size: '1024'
    srate: channel_samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"disturb2"'
    size: '1024'
    srate: channel_samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"disturb3"'
    size: '1024'
    srate: channel_samp_rate
    type: complex
  states: {}

connections:
- [blocks_repack_bits_bb_info, '0', network_udp_sink_info, '0']
- [blocks_repack_bits_bb_jam1, '0', network_udp_sink_jam1, '0']
- [blocks_repack_bits_bb_jam2, '0', network_udp_sink_jam2, '0']
- [blocks_repack_bits_bb_jam3, '0', network_udp_sink_jam3, '0']
- [digital_correlate_access_code_tag_xx_info, '0', epy_block_info, '0']
- [digital_correlate_access_code_tag_xx_jam1, '0', epy_block_jam1, '0']
- [digital_correlate_access_code_tag_xx_jam2, '0', epy_block_jam2, '0']
- [digital_correlate_access_code_tag_xx_jam3, '0', epy_block_jam3, '0']
- [digital_gfsk_demod_info, '0', digital_correlate_access_code_tag_xx_info, '0']
- [digital_gfsk_demod_jam1, '0', digital_correlate_access_code_tag_xx_jam1, '0']
- [digital_gfsk_demod_jam2, '0', digital_correlate_access_code_tag_xx_jam2, '0']
- [digital_gfsk_demod_jam3, '0', digital_correlate_access_code_tag_xx_jam3, '0']
- [epy_block_info, '0', blocks_repack_bits_bb_info, '0']
- [epy_block_jam1, '0', blocks_repack_bits_bb_jam1, '0']
- [epy_block_jam2, '0', blocks_repack_bits_bb_jam2, '0']
- [epy_block_jam3, '0', blocks_repack_bits_bb_jam3, '0']
- [freq_xlating_fir_filter_info, '0', digital_gfsk_demod_info, '0']
- [freq_xlating_fir_filter_info, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_jam1, '0', digital_gfsk_demod_jam1, '0']
- [freq_xlating_fir_filter_jam1, '0', qtgui_time_sink_x_0_0, '0']
- [freq_xlating_fir_filter_jam2, '0', digital_gfsk_demod_jam2, '0']
- [freq_xlating_fir_filter_jam2, '0', qtgui_time_sink_x_0_0_0, '0']
- [freq_xlating_fir_filter_jam3, '0', digital_gfsk_demod_jam3, '0']
- [freq_xlating_fir_filter_jam3, '0', qtgui_time_sink_x_0_0_1, '0']
- [iio_fmcomms2_source_0, '0', freq_xlating_fir_filter_info, '0']
- [iio_fmcomms2_source_0, '1', freq_xlating_fir_filter_jam1, '0']
- [iio_fmcomms2_source_0, '1', freq_xlating_fir_filter_jam2, '0']
- [iio_fmcomms2_source_0, '1', freq_xlating_fir_filter_jam3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.1
