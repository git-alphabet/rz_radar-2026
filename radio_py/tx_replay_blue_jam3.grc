options:
  parameters:
    comment: Replay recorded Blue level-3 jamming IQ.
    generate_options: no_gui
    id: tx_replay_blue_jam3
    output_language: python
    title: Blue level-3 jamming replay transmitter
  states: {}

blocks:
- name: pluto_uri
  id: variable
  parameters:
    comment: AntSDR/Pluto-compatible IIO URI
    value: '"ip:192.168.1.10"'
  states: {}
- name: recording_path
  id: variable
  parameters:
    comment: Complex64 IQ recording centered on Blue level-3 jamming wave
    value: '"C:/Users/GMD777/Desktop/radio_py/RX_BLUE_ganrao_3"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Recording sample rate. Offline validation shows this file is 2 MS/s IQ.
    value: 2e6
  states: {}
- name: tx_attenuation
  id: variable
  parameters:
    comment: Pluto/FMComms2 TX attenuation in dB. Lower means stronger output.
    value: '10.0'
  states: {}
- name: tx_center_freq
  id: variable
  parameters:
    comment: Blue level-3 jamming frequency from the rulebook
    value: 434.320e6
  states: {}
- name: tx_rf_bandwidth
  id: variable
  parameters:
    comment: Wider hardware filter for replay; baseband channel filter still selects jam3.
    value: 1.0e6
  states: {}
- name: tx_scale
  id: variable
  parameters:
    comment: Additional complex IQ scale. Recording peak is about 0.35, so 1.0 does not clip.
    value: '1.0'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Repeats the captured Blue level-3 jamming IQ file continuously.
    file: recording_path
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_scale
    type: complex
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: int(tx_rf_bandwidth)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Design'''
    fpass: 0.45e6
    frequency: int(tx_center_freq)
    fstop: 0.60e6
    len_tag_key: '""'
    rf_port_select: '''A'''
    samplerate: int(samp_rate)
    tx1_en: 'True'
    tx2_en: 'False'
    type: fc32
    uri: pluto_uri
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_fmcomms2_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
